# Keil uVision project STM32F103.uvprojx, settings and files
target STM32F103 (6240000::V6.24::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: STM32F103 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\OTA_CAN
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group UDS
    ../OTA_CAN/: can_ring_buffer.c crypto_aes_cmac.c dtc_nvm_adapter.c dtc_store.c dtc_table_85.c isotp_fd.c svc_authentication.c svc_clear_dtc.c svc_comm_control.c svc_control_dtc.c svc_diag_session.c svc_download.c svc_dyn_did.c svc_ecu_reset.c svc_io_control.c svc_link_ctrl.c svc_periodic_did.c svc_read_address.c svc_read_did.c svc_read_dtc.c svc_routine_control.c svc_security_access.c svc_tester_present.c svc_upload.c svc_write_address.c svc_write_did.c uds_did_table.c uds_platform_time.c uds_server.c uds_session.c uds_wear_leveling.c
software components: CMSIS:CORE 6.2.0
